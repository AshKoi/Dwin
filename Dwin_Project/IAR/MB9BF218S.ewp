# IAR project MB9BF218S.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MB9BF218S Fujitsu MB9BF218S
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pe035
  ICCARM.CCIncludePath2: ..\drivers; ..\drivers\common; ..\drivers\bootloader; ..\drivers\ZLIB; ..\drivers\ethernet; ..\drivers\mfs; ..\drivers\lwip; ..\drivers\lwip\api; ..\drivers\lwip\arch; ..\drivers\lwip\core; ..\drivers\lwip\include; ..\drivers\lwip\include\arch; ..\drivers\lwip\include\ipv4; ..\drivers\lwip\include\lwip; ..\drivers\lwip\include\netif; ..\drivers\lwip\netif; ..\drivers\lwip\others; ..\drivers\lwip\utility; ..\uCOS_II_V286\CPU\IAR\; ..\uCOS_II_V286\Source\; ..\drivers\lwip; ..\drivers\lwip\include; ..\drivers\lwip\include\arch; ..\drivers\lwip\include\lwip; ..\drivers\lwip\include\ipv4; ..\drivers\lwip\include\ipv6; ..\drivers\lwip\include\netif; ..\drivers\lwip\core\ipv4; ..\drivers\lwip\netif; ..\drivers\lwip\netif\ppp; ..\drivers\lwip\web; ..\drivers\lwip\utility; ..\drivers\lwip\others; ..\drivers\fat32; ..\drivers\usb\Usb; ..\drivers\usb\dbg; ..\drivers\usb\UsbHost; ..\drivers\usb\UsbFunction; ..\drivers\usb\UsbHost\Classes; ..\drivers\usb\UsbHost\Classes\MassStorage; ..\drivers\bootloader; ..\main\; ..\main\AppCfg\; ..\main\base\; ..\main\comm\; ..\main\comm\prot\; ..\main\comm\gprsmodl\; ..\main\Disp\; ..\main\MainCtrl\; ..\main\MainCtrl\Modl\; ..\main\Mem\; ..\main\Tool\; ..\main\Tool\CarrCol; ..\main\Tool\CarrCol\CarrMod; ..\main\Tool\Interface; ..\main\Tool\Ac7022; ..\main\Tool\Gw3761Proc; ..\main\Tool\Gw645Proc; ..\main\Tool\Rs485Col; ..\main\Tool\PulseColProc; ..\main\Tool\RemotCtrl; ..\main\Tool\GB698Proc; ..\main\Tool\WiringProc; ..\main\Tool\Dwin
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MB9BF218S.bin
  postbuild: "config\AddCrcTail.exe" "$EXE_DIR$\$PROJ_FNAME$.bin"
  ILINK.IlinkOutputFile: MB9BF218S.out
  ILINK.IlinkIcfFile: MB9BF218S.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration library (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF506R Fujitsu MB9BF506R
  ICCARM.CCIncludePath2: ..\drivers; ..\drivers\common; ..\drivers\bootloader; ..\drivers\ZLIB; ..\drivers\ethernet; ..\drivers\mfs; ..\uCOS_II_V286\CPU\IAR\; ..\uCOS_II_V286\Source\; ..\drivers\lwip; ..\drivers\lwip\include; ..\drivers\lwip\include\arch; ..\drivers\lwip\include\lwip; ..\drivers\lwip\include\ipv4; ..\drivers\lwip\include\ipv6; ..\drivers\lwip\include\netif; ..\drivers\lwip\core\ipv4; ..\drivers\lwip\netif; ..\drivers\lwip\netif\ppp; ..\drivers\lwip\web; ..\drivers\lwip\utility; ..\drivers\lwip\others; ..\drivers\fat32; ..\drivers\usb\Usb; ..\drivers\usb\dbg; ..\drivers\usb\UsbHost; ..\drivers\usb\UsbFunction; ..\drivers\usb\UsbHost\Classes; ..\drivers\usb\UsbHost\Classes\MassStorage; ..\drivers\bootloader
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  group APP
    ../main/: main.c Main.h
  group APP/AppCfg
    ../main/AppCfg/: AppCfg.c AppCfg.h Version.h
  group APP/base
    ../main/base/: AppHead.h Base.c Base.h ChkCrc.C ChkCrc.h DataItem.c DataItem.h Macro.h SoftTimer.c SoftTimer.h SysRes.c SysRes.h Table.h TimerCount.c TimerCount.h
  group APP/comm
    ../main/comm/: ethnetlink.c ethnetlink.h ethnetserlink.c ethnetserlink.h fifo.h LinkCom.a linkcom.h linkcomExt.c linkcomExt.h locallink.c locallink.h rmotlink.c rmotlink.h
  group APP/comm/gprsmodl
    ../main/comm/gprsmodl/: Telit.c Telit.h
  group APP/comm/prot
    ../main/comm/prot/: AssitProt.c AssitProt.h Gw3761.c Gw3761.h Gw3762.c Gw3762.h Gw698.c Gw698.h meter645.c Meter645.h
  group APP/Disp
    ../main/Disp/: Disp.a Guiwin.h GuiwinCfg.c GuiwinCfg.h Key.c Key.h Lcd.c Lcd.h
  group APP/MainCtrl
    ../main/MainCtrl/: Fun.c Fun.h IntProc.c IntProc.h MSecTask.c MSecTask.h SecTask.c SecTask.h
  group APP/MainCtrl/Mod
    ../main/MainCtrl/Modl/: AppDog.c AppDog.h PowerOn.c PowerOn.h Reset.c Reset.h
  group APP/Mem
    ../main/Mem/: FlashFile.c FlashFile.h FlashFileExt.c FlashFileExt.h MemData.c MemData.h MemDrv.c MemDrv.h MemDrvExt.c MemDrvExt.h MemPrm.c MemPrm.h MemTbl.c MemTbl.h
  group APP/Tool/Ac7022
    ../main/Tool/Ac7022/: Ac7022.c Ac7022.h
  group APP/Tool/CarrCol
    ../main/Tool/CarrCol/: CarrCol.c CarrCol.h
  group APP/Tool/CarrCol/CarrMod
    ../main/Tool/CarrCol/CarrMod/: Dingxin.c Dingxin.h
  group APP/Tool/Dwin
    ../main/Tool/Dwin/: Dwin.c
  group APP/Tool/GB698Proc
    ../main/Tool/Gw698Proc/: GB698ActionRequest.c GB698ActionRequest.h GB698GetRequest.c GB698GetRequest.h GB698ProxyRequest.c GB698ProxyRequest.h GB698ReportRequest.c GB698ReportRequest.h GB698SecurityTrans.c GB698SecurityTrans.h GB698SetRequest.c GB698SetRequest.h
  group APP/Tool/Gw3761Proc
    ../main/Tool/Gw3761Proc/: FileTrans.c FileTrans.h GB3761CtrlCmd.c GB3761CtrlCmd.h GB3761GetClassI.c GB3761GetClassI.h GB3761GetClassII.c GB3761GetClassII.h GB3761GetPrm.c GB3761GetPrm.h GB3761GetPrmExt.c GB3761GetPrmExt.h GB3761SetPrm.c GB3761SetPrm.h GB3761SetPrmExt.c GB3761SetPrmExt.h GB3761Trans.c GB3761Trans.h
  group APP/Tool/Gw645Proc
    ../main/Tool/Gw645Proc/: Gb07.c Gb07.h Gb97.c Gb97.h
  group APP/Tool/Interface
    ../main/Tool/Interface/: AutoTest.c AutoTest.h Guimenu.c Guimenu.h IdleTask.c IdleTask.h Login.c Login.h ZBMenu.c ZBMenu.h
  group APP/Tool/PulseColProc
    ../main/Tool/PulseColProc/: PulseCol.c PulseCol.h
  group APP/Tool/RemotCtrl
    ../main/Tool/RemotCtrl/: RemotCtrl.c RemotCtrl.h
  group APP/Tool/Rs485Col
    ../main/Tool/Rs485Col/: Rs485Col.c Rs485Col.h
  group APP/Tool/WiringProc
    ../main/Tool/WiringProc/: WiringProc.c
  group common
    ../drivers/common/: mb9bf218s.h
    ../common/: startup_mb9bf21x.s system_mb9bf21x.c
  group drivers
    ../drivers/: apierrno.h BSP.h bt_fm3.h COMM.h dmac_fm3.h FM24CL16.h global.h GPRS.h RX8025T.h SST25F032.h uart.h
    ../source/: ATT7022.c BSP.c bt_fm3.c COMM.C dmac_fm3.c FM24CL16.c Global.c GPRS.c io_fm3.c PCA9555.C RX8025T.c SST25F032.c UART.c
    ../main/Disp/: BU97950FUV.C BU97950FUV.h
    ../source/ZLIB/: crc32.c
    ../drivers/ZLIB/: crc32.h
    ../source/mfs/: mfs_fm3.c
    ../drivers/mfs/: mfs_fm3.h uart_fm3.h
    ../source/mfs/uart/: uart_fm3.c
  group drivers/bootloader
    ../drivers/bootloader/: bootloader.h bootloaderapi.h srecordparser.h
    ../source/bootloader/: bootloaderapi.c srecordparser.c
  group drivers/bootloader/flash
    ../source/bootloader/flash/: flash.c
    ../drivers/bootloader/: flash.h
  group drivers/fat32
    ../source/fat32/: diskio.c ff.c
    ../drivers/fat32/: diskio.h ff.h ffconf.h integer.h
  group drivers/lwip
    ../source/lwip/: emac_api.c emac_fm3.c ping.c socketapi.c tcpecho.c udpecho.c
  group drivers/lwip/api
    ../source/lwip/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group drivers/lwip/arch
    ../source/lwip/arch/: lib_arch.c sys_arch.c
  group drivers/lwip/core
    ../source/lwip/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group drivers/lwip/core/ipv4
    ../source/lwip/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group drivers/lwip/core/snmp
    ../source/lwip/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
  group drivers/lwip/include
    ../drivers/lwip/: emac_api.h emac_fm3.h ping.h socketapi.h tcpecho.h udpecho.h
  group drivers/lwip/include/arch
    ../drivers/lwip/include/arch/: arch_init.h cc.h lib_arch.h lwipopts.h perf.h sys_arch.h
  group drivers/lwip/include/ipv4
    ../drivers/lwip/include/ipv4/lwip/: autoip.h icmp.h igmp.h inet.h inet_chksum.h ip.h ip_addr.h ip_frag.h
  group drivers/lwip/include/lwip
    ../drivers/lwip/include/lwip/: api.h api_msg.h arch.h debug.h def.h dhcp.h dns.h err.h init.h mem.h memp.h memp_std.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h snmp_asn1.h snmp_msg.h snmp_structs.h sockets.h stats.h sys.h tcp.h tcpip.h udp.h
  group drivers/lwip/include/netif
    ../drivers/lwip/include/netif/: etharp.h loopif.h ppp_oe.h slipif.h
  group drivers/lwip/netif
    ../source/lwip/netif/: etharp.c ethernetif.c loopif.c slipif.c
  group drivers/lwip/netif/ppp
    ../source/lwip/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c ppp_oe.c pppdebug.c randm.c vj.c
  group drivers/lwip/others
    ../source/lwip/others/fm3/periph/emac/: dm9161.c emac.c
    ../drivers/lwip/others/fm3/periph/emac/: dm9161.h dm9161_define.h emac.h
  group drivers/lwip/utility
    ../drivers/lwip/utility/: assert.h trace.h
  group drivers/USB
    ../source/: USBApi.C
    ../drivers/: USBApi.h
  group drivers/USB/Usb
    ../drivers/usb/Usb/: Usb.h UsbInit.h UsbRegisters.h UsbSofTimeout.h UsbSpec.h
    ../source/usb/Usb/: UsbInit.c UsbSofTimeout.c
  group drivers/USB/UsbFunction
    ../source/usb/UsbFunction/: UsbClass.c UsbDma.c UsbFunction.c
    ../drivers/usb/UsbFunction/: UsbClass.h UsbDescriptors.h UsbDma.h UsbFunction.h UsbFunctionHW.h
  group drivers/USB/UsbHost
    ../source/usb/UsbHost/: UsbClassSupervisor.c UsbHost.c
    ../drivers/usb/UsbHost/: UsbClassSupervisor.h UsbHost.h UsbHostHW.h
  group drivers/USB/UsbHost/Classes
    ../drivers/usb/UsbHost/Classes/: ClassDriverTable.h
  group drivers/USB/UsbHost/Classes/MassStorage
    ../source/usb/UsbHost/Classes/MassStorage/: StorageApi.c UsbMassStorage.c
    ../drivers/usb/UsbHost/Classes/MassStorage/: StorageApi.h UsbMassStorage.h
  group system/uCOSII/port
    ../uCOS_II_V286/CPU/IAR/: Os_cpu.h os_cpu_a.asm os_cpu_c.c
  group system/uCOSII/src
    ../uCOS_II_V286/Source/: os_core.c os_dbg.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
